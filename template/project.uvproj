# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./lib/: utilities.c defines.h stdint.h utilities.h LCD1602.c LCD1602.h matrix_key.c matrix_key.h timer.c timer.h individual_key.c individual_key.h nixie.c nixie.h REGX52.h interrupt.h UART.c UART.h 51++.h
